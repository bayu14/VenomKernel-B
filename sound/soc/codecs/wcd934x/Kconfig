## sound/soc/codecs/wcd934x/Kconfig
```kconfig
menu "CODEC drivers"

config SOUND_CONTROL
	bool "Sound control for wcd934x"

endmenu
```
